Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_70.040_SABONETEIRA_PRESSÃO_PRESS_LÍQUIDO_PAREDE.IFC
Time: 2023-12-08T20:48:00
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: DRACO_70.040_SABONETEIRA_PRESSÃO_PRESS_LÍQUIDO_PAREDE
In: Default Storey
Material: AISI 304
PSet_Mass_Property - Mass Measure: 23.8863; Area Measure: 0.134669 m2; Volume Measure: 0.00298578 m3
